# Keil uVision project hello_world_cm0plus.uvprojx, settings and files
target hello_world_cm0plus Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC54114J256BD64:M0plus NXP
  pack: Keil.LPC54000_DFP.2.2.0
  cpu: CPUTYPE("Cortex-M0+")
  output: hello_world_cm0plus.out
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bincombined --bincombined_base=0x20010000 --output=$Lcore1_image.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_LPC54114J256BD64_cm0plus
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../../CMSIS/Include;../../../../../../devices;../../../../../../devices/LPC54114;../../../..;..;../..;../../../../../../devices/LPC54114/drivers;../../../../../../devices/LPC54114/utilities;../../../../../../platform/drivers/mailbox;../../../../../../middleware/multicore_2.2.0/mcmgr/src;..\..\app
  asm define: CPU_LPC54114J256_M0, DEBUG,__CC_ARM,KEIL, SLAVEBOOT, NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x8000
  scatter file: LPC54114J256_cm0plus.scf
  link misc: ../../../../../../devices/LPC54114/arm/keil_lib_power_m0.lib 
--remove
  group doc
    ../: readme.txt
  group startup
    ../../../../../../devices/LPC54114/arm/: startup_LPC54114_cm0plus.s
    ../../../../../../devices/LPC54114/: system_LPC54114_cm0plus.c system_LPC54114_cm0plus.h
  group drivers
    ../../../../../../devices/LPC54114/drivers/: fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iocon.h fsl_gpio.h fsl_gpio.c fsl_mailbox.h fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_reset.h fsl_reset.c fsl_power.h fsl_power.c fsl_i2c.c
  group source
    ../: hello_world_core1.c
    ../../app/: app_si70xx.c
  group board
    ../../: pin_mux.c pin_mux.h
    ../: board.c board.h clock_config.c clock_config.h
  group mcmgr-mcmgr
    ../../../../../../middleware/multicore_2.2.0/mcmgr/src/: mcmgr_internal_core_api_lpc54114.c mcmgr.c mcmgr.h mcmgr_internal_core_api.h
  group utilities
    ../../../../../../devices/LPC54114/utilities/: fsl_debug_console.c fsl_debug_console.h
target hello_world_cm0plus Release (ARM-ADS)
  device: LPC54114J256BD64:M0plus NXP
  pack: Keil.LPC54000_DFP.2.2.0
  cpu: CPUTYPE("Cortex-M0+")
  output: hello_world_cm0plus.out
  AfterMake: as above
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_LPC54114J256BD64_cm0plus
  c misc: as above
  c include: ../../../../../../CMSIS/Include;../../../../../../devices;../../../../../../devices/LPC54114;../../../..;..;../..;../../../../../../devices/LPC54114/drivers;../../../../../../devices/LPC54114/utilities;../../../../../../platform/drivers/mailbox;../../../../../../middleware/multicore_2.2.0/mcmgr/src
  asm define: CPU_LPC54114J256_M0, NDEBUG,__CC_ARM,KEIL, SLAVEBOOT, NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x8000
  scatter file: LPC54114J256_cm0plus.scf
  link misc: as above
