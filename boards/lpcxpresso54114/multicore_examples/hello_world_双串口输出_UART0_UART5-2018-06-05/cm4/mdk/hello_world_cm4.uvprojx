# Keil uVision project hello_world_cm4.uvprojx, settings and files
target hello_world_cm4 Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC54114J256BD64:M4 NXP
  pack: Keil.LPC54000_DFP.2.2.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: hello_world_cm4.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CORE1_IMAGE_COPY_TO_RAM, CPU_LPC54114J256BD64_cm4
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186 
 
--gnu
  c include: ../../../../../../CMSIS/Include;../../../../../../devices;../../../../../../devices/LPC54114;../../../..;..;../..;../../../../../../devices/LPC54114/drivers;../../../../../../devices/LPC54114/utilities;../../../../../../platform/drivers/mailbox;../../../../../../middleware/multicore_2.2.0/mcmgr/src;..\..\app;..\..\inc;..\..\..\..\..\..\devices\LPC54114\cmsis_drivers;..\..\..\..\..\..\CMSIS\Driver\Include
  asm define: CPU_LPC54114J256_M4, DEBUG,__CC_ARM,KEIL
  asm include: ../../cm0plus/mdk/debug
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x8000
  scatter file: LPC54114J256_cm4.scf
  link misc: ../../../../../../devices/LPC54114/arm/keil_lib_power.lib 
--remove
  group source
    ../: incbin.s hello_world_core0.c
  group doc
    ../: readme.txt
  group startup
    ../../../../../../devices/LPC54114/arm/: startup_LPC54114_cm4.s
    ../../../../../../devices/LPC54114/: system_LPC54114_cm4.c system_LPC54114_cm4.h
  group drivers
    ../../../../../../devices/LPC54114/drivers/: fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iocon.h fsl_gpio.h fsl_gpio.c fsl_mailbox.h fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_power.h fsl_power.c fsl_reset.h fsl_reset.c fsl_i2c.c fsl_spi.c fsl_inputmux.c fsl_pint.c fsl_ctimer.c fsl_sctimer.c fsl_dma.c fsl_usart_dma.c
    ../../../../../../devices/LPC54114/cmsis_drivers/: fsl_usart_cmsis.c
  group board
    ../../: pin_mux.c pin_mux.h
    ../: board.c board.h clock_config.c clock_config.h
  group mcmgr-mcmgr
    ../../../../../../middleware/multicore_2.2.0/mcmgr/src/: mcmgr_internal_core_api_lpc54114.c mcmgr.c mcmgr.h mcmgr_internal_core_api.h
  group utilities
    ../../../../../../devices/LPC54114/utilities/: fsl_debug_console.c fsl_debug_console.h
  group hal
    ../../app/: app_si70xx.c app_interrupt.c app_led.c app_dev_ctrl.c app_lcd.c app_spiflash.c app_key.c app_realy.c app_beep.c smart_plc.c protocol_smart.c auto_report.c auto_report_app.c
  group src
    ../../src/: alloter.c
    ../../app/: utils.c
target hello_world_cm4 Release (ARM-ADS)
  device: LPC54114J256BD64:M4 NXP
  pack: Keil.LPC54000_DFP.2.2.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: hello_world_cm4.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CORE1_IMAGE_COPY_TO_RAM, CPU_LPC54114J256BD64_cm4
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../../CMSIS/Include;../../../../../../devices;../../../../../../devices/LPC54114;../../../..;..;../..;../../../../../../devices/LPC54114/drivers;../../../../../../devices/LPC54114/utilities;../../../../../../platform/drivers/mailbox;../../../../../../middleware/multicore_2.2.0/mcmgr/src
  asm define: CPU_LPC54114J256_M4, NDEBUG,__CC_ARM,KEIL
  asm include: ../../cm0plus/mdk/release
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x8000
  scatter file: LPC54114J256_cm4.scf
  link misc: as above
